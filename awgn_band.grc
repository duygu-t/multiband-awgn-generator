options:
  parameters:
    author: Duygu
    description: QT GUI
    generate_options: qt_gui
    id: multiband_awgn
    output_language: python
    title: Multiband AWGN Generator
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: '[3000, 1000, 3000]'
  states: {}
- name: center_frequency
  id: variable
  parameters:
    value: '[5e3, 10e3, 15e3]'
  states: {}
- name: num_samples
  id: variable
  parameters:
    value: '65536'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '10000'
    low_cutoff_freq: '5000'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
    vlen: num_samples
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: num_samples
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import sys

      # GNU Radio'nun yolu bulması için masaüstü klasörünü ekliyoruz
      sys.path.append(r"C:\Users\Duygu\Desktop\awgn_project")
      import awgn_band 

      class blk(gr.decim_block):
          def __init__(self, sample_rate=32000.0, num_samples=65536, center_freqs=[5000, 10000], bandwidths=[1000, 1000]):
              # GNU Radio 3.8+ ve sonraki modern sürümler için güvenli decimation bloğu başlatma yöntemi
              gr.decim_block.__init__(
                  self,
                  name='Multi-band AWGN Gen',
                  in_sig=None,
                  out_sig=[(np.complex64, num_samples)],
                  decim=1 # Eksik olan ve hataya sebep olan parametre buydu!
              )
              self.sample_rate = sample_rate
              self.num_samples = num_samples
              self.center_freqs = center_freqs
              self.bandwidths = bandwidths

          def work(self, input_items, output_items):
              # Orijinal awgn_band.py dosyasındaki fonksiyonu çağırıyoruz
              filtered_noise = awgn_band.generate_awgn(self.sample_rate, self.num_samples, self.center_freqs, self.bandwidths)
              output_items[0][:] = filtered_noise
              return len(output_items[0])
    bandwidths: bandwidth
    center_freqs: center_frequency
    num_samples: num_samples
    sample_rate: samp_rate
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '2000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Band Pass"'
    nconnections: '2'
    type: complex
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_throttle2_0, '0']
- [band_pass_filter_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', band_pass_filter_0, '0']
- [blocks_throttle2_0, '0', low_pass_filter_0, '0']
- [blocks_throttle2_1, '0', blocks_vector_to_stream_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_freq_sink_x_0, '1']
- [epy_block_0, '0', blocks_throttle2_1, '0']
- [low_pass_filter_0, '0', blocks_add_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
